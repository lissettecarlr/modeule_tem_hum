# Keil uVision project temperature_humidity_module.uvprojx, settings and files
target pro (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temperature_humidity_module +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Lib;..\驱动;.\Lib\System\Interrupt;.\Lib\System\TaskManager;.\Lib\ToolBox\Buffer;.\Lib\ToolBox\Math;.\Lib\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ./Lib/: ADC.cpp ADC.h AM2302.cpp AM2302.h USART.cpp USART.h GPIO.cpp GPIO.h ESP8266.cpp ESP8266.h Memory.cpp Memory.h
  group app
    ./: main.cpp
    ./Lib/: transmission.cpp WIFI_Memory.cpp WIFI_Memory.h Hint.cpp Hint.h
  group System
    ./Lib/System/Interrupt/: Interrupt.cpp
    ./Lib/System/TaskManager/: TaskManager.cpp TaskManager.h
    ./Lib/: Interrupt.h
  group ToolBox
    ./Lib/ToolBox/Buffer/: FIFOBuffer.h
    ./Lib/ToolBox/Math/: MathTool.h Quaternion.cpp Quaternion.h Vector3.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0

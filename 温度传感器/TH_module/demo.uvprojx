# Keil uVision project demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\lib;.\usr;.\RTE;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group usr
    ./usr/: main.cpp HCHO.cpp HCHO.h transmission.cpp transmission.h WIFI_Memory.cpp WIFI_Memory.h
  group lib
    ./lib/: ADC.cpp ADC.h Configuration.h ESP8266.cpp ESP8266.h FIFOBuffer.h GPIO.cpp GPIO.h Hint.cpp Hint.h Interrupt.cpp Interrupt.h Memory.cpp Memory.h TaskManager.cpp TaskManager.h USART.cpp USART.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
